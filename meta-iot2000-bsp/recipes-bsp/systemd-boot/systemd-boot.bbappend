
EXTRA_OEMAKE_append_intel-x86-common = ' EFI_CC="${CC}" '

