# meta-swupdate ships a bbappend for u-boot-fw-utils but u-boot is not relevant
# for our platform, work-around this with a dummy recipe
LICENSE = "MIT"
