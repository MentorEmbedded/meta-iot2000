
DEPENDS += "cross-localedef-native"

